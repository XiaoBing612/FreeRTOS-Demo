# Keil uVision project ISO_Template.uvproj, settings and files
target ISO_Template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ISO_Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM3;..\..\Task\bsp_task_led;..\..\HardWare\bsp_led;..\..\User\bsp_board;..\..\User\bsp_includes;..\..\HardWare\bsp_key;..\..\Task\bsp_task_key;..\..\User\bsp_delay;..\..\HardWare\bsp_usart1;..\..\User\bsp_bitband
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h FreeRTOSConfig.h
    ../../User/bsp_includes/: includes.h
    ../../User/bsp_board/: board.c
    ../../User/bsp_delay/: delay.c
    ../../User/bsp_bitband/: bitband.h
  group DOC
    ../../Doc/: readme.txt
  group FreeRTOS/Source
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
  group HARDWARE
    ../../HardWare/bsp_led/: led.c
    ../../HardWare/bsp_key/: key.c
    ../../HardWare/bsp_usart1/: usart1.c
  group TASK
    ../../Task/bsp_task_led/: task_led.c
    ../../Task/bsp_task_key/: task_key.c
